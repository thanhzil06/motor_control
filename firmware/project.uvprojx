# Keil uVision project project.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F40_41xxx, HSE_VALUE=8000000
  c include: ..\Project;.\STM32F4xx_StdPeriph_Driver\inc;C:\Program Files\Polyspace\R2019a\extern\include;C:\Program Files\Polyspace\R2019a\simulink\include;C:\Program Files\Polyspace\R2019a\rtw\c\ert;C:\Program Files\Polyspace\R2019a\rtw\c\src;C:\Program Files\Polyspace\R2019a\rtw\c\src\ext_mode\common;.\Matlab
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./: driver.c system_stm32f4xx.c system_timetick.c startup_stm32f40_41xxx.s main.c
  group Stm32f4
    ./STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_tim.c
  group Matlab
    ./Matlab/: controllers.c controllers_data.c
software components: CMSIS:CORE 5.4.0
